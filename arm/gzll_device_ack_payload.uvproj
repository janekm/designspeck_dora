# Keil uVision project gzll_device_ack_payload.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: gzll_device_ack_payload +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\nrf51_Sdk\Include\gzll;..\nrf51_Sdk\Include;..\
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --info=inline
  group app
    ../: main_device_ack_payload.c
  group system
    ../nrf51_Sdk/Source/templates/arm/: arm_startup_nrf51.s
    ../nrf51_Sdk/Source/templates/: system_nrf51.c
  group lib
    ../nrf51_Sdk/Lib/gzll/arm/: gzll_arm.lib
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: gzll_device_ack_payload +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include\gzll;..\..\..\..\..\Include;..\
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --info=inline
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: as above
  output: gzll_device_ack_payload +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include\gzll;..\..\..\..\..\Include;..\
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  link misc: --info=inline
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: gzll_device_ack_payload +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include\gzll;..\..\..\..\..\Include;..\
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
  link misc: --info=inline
